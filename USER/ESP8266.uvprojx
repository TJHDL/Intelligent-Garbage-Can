# Keil uVision project ESP8266.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HC05 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER,USE_HAL_LEGACY,STM32F103xB
  c misc: --C99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\USART2;..\HARDWARE\TIMER;..\ATK-ESP8266;..\MALLOC;..\HARDWARE\SMG;..\HARDWARE\DHT11;..\HARDWARE\BEEP;..\HARDWARE\GPIO;..\HARDWARE\EXTI;..\HARDWARE\PWM;..\HARDWARE\IIC;..\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xb.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/IIC/: myiic.c
  group ATK-ESP8266
    ../ATK-ESP8266/: common.c wifista.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: README.TXT
